Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-22T13:32:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 22 13:32:43 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7b3ee4da-c21c-4361-b68a-f795bfa2d582\c4fdb385-b0c4-4bf0-947c-4aa49f319688\ifc * Database version: 5507 * Database creation date: Wed Feb 22 13:32:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 22 13:32:43 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 22 13:32:43 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12336280_OER_KFN4395CD_WS:38439534_OER_12336280_KFN4395CD_WS, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38439534_OER_12336280_KFN4395CD_WS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38439534_OER_12336280_KFN4395CD_WS
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 2010 mm; Depth: 675 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_BRWS, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355623
Description: Flow; FlowDirection: SOURCEANDSINK
